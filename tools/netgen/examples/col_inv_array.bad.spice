* NGSPICE file created from test_col_inv_array.ext - technology: sky130A

.subckt ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1 w_348_n36# a_0_83# a_384_0#
+ a_384_83# SUB a_0_0# a_n38_53#
X0 a_384_83# a_n38_53# a_384_0# w_348_n36# sky130_fd_pr__pfet_01v8 ad=0.689 pd=5.73 as=0.689 ps=5.73 w=2.6 l=0.15
X1 a_0_83# a_n38_53# a_0_0# SUB sky130_fd_pr__nfet_01v8 ad=0.371 pd=3.33 as=0.371 ps=3.33 w=1.4 l=0.15
.ends

.subckt test_col_inv_array_cell_inv li_5_94# ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ SUB ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53# ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
Xptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0 ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ li_5_94# ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0# li_5_94# SUB ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53# ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1
.ends

.subckt test_col_inv_array_cell test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_inv_0/li_5_94#
Xtest_col_inv_array_cell_inv_0 test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ SUB test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_inv
.ends

.subckt test_col_inv_array_array_inst test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/li_5_94#
+ test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/li_5_94#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/li_5_94#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/li_5_94#
+ test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/li_5_94# SUB test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/li_5_94#
Xtest_col_inv_array_cell_4 test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_4/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_5 test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_5/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_6 test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_6/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_20 test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_20/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_30 test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_30/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_31 test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_31/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_7 test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_7/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_10 test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_10/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_21 test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_21/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_8 test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_8/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_11 test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_11/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_22 test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_22/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_9 test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_9/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_12 test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_12/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_23 test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_23/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_13 test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_13/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_24 test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_24/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_14 test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_14/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_25 test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_25/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_15 test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_15/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_26 test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_26/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_16 test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_16/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_27 test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_27/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_17 test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_17/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_18 test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_18/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_28 test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_28/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_29 test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_29/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_19 test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_19/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_0 test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_0/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_1 test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_1/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_2 test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_2/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
Xtest_col_inv_array_cell_3 test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_n38_53#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_0_0#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/w_348_n36#
+ SUB test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/ptx__nmos_svt_1400_150_1__pmos_svt_2600_150_1_0/a_384_0#
+ test_col_inv_array_cell_3/test_col_inv_array_cell_inv_0/li_5_94# test_col_inv_array_cell
.ends

.subckt col_inv_array din_b_0 din_b_1 din_b_2 din_b_3 din_b_4 din_b_5 din_b_6
+ din_b_7 din_b_8 din_b_9 din_b_10 din_b_11 din_b_12 din_b_13 din_b_14 din_b_15 din_b_16
+ din_b_17 din_b_18 din_b_19 din_b_20 din_b_21 din_b_22 din_b_23 din_b_24 din_b_25
+ din_b_26 din_b_27 din_b_28 din_b_29 din_b_30 din_b_31 din_0 din_1 din_2 din_3 din_4
+ din_5 din_6 din_7 din_8 din_9 din_10 din_11 din_12 din_13 din_14 din_15 din_16 din_17
+ din_18 din_19 din_20 din_21 din_22 din_23 din_24 din_25 din_26 din_27 din_28 din_29
+ din_30 din_31 vdd vss
Xtest_col_inv_array_array_inst_0 vss vdd din_24 vss vdd din_b_21 vss vdd din_b_3 vdd
+ vdd din_23 vss din_6 din_b_30 vdd vdd vdd din_16 din_b_2 din_b_20 vdd vdd din_29
+ vss din_b_29 vss vdd vss vdd vdd din_b_19 vdd vdd vss vdd vss din_24 din_b_28 vss
+ vdd din_7 vdd vdd vdd vdd din_b_18 din_17 din_b_27 vss din_30 vdd vdd vss vdd din_2
+ vdd vss din_b_17 din_12 din_b_26 din_b_11 vdd vdd din_25 vss vdd vdd vdd din_8 din_b_16
+ vdd din_b_10 din_18 vdd din_b_25 vdd vdd vss vss din_31 vdd vdd din_b_15 din_3 vss
+ vdd din_b_9 din_b_24 din_13 vdd vdd vdd vdd vdd din_26 vss din_b_14 vss vdd vss
+ din_9 din_b_8 din_b_23 vdd vdd din_19 vdd vss vdd vss din_b_13 vss vdd vss din_b_7
+ din_4 din_b_22 vdd din_14 din_b_1 vdd din_b_12 vdd din_27 din_0 vss vdd din_b_6
+ vss vss din_10 vdd vdd vdd din_b_0 vdd din_20 vss vdd vss din_22 din_b_5 vdd vdd
+ vss vdd din_5 vdd din_15 din_b_4 din_1 din_28 vdd vss vss vss vdd vdd din_11 din_b_31
+ test_col_inv_array_array_inst
.ends
